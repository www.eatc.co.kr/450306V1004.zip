# Autodesk Inventor assembly: 조립품1
## iProperties
Created: 2015-03
Part Number: 조립품1
Document SubType Name: Assembly
Designer: now102
Author: now102
